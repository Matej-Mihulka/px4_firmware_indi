## src/modules/indi_controller/Kconfig
```kconfig
menuconfig MODULES_INDI_CONTROLLER
	bool "indi_controller"
	default n
	---help---
		Enable the custom INDI controller.
```
